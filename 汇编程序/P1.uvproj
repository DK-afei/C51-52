# Keil uVision project P1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: P1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 1.c
  group Source Group 2
    ./: 2.c
  group Source Group 3
    ./: 3.c
  group Source Group 4
    ./: 4.c
  group Source Group 5
    ./: 5.c
  group Source Group 6
    ./: 6.c
  group Source Group 7
    ./: 7.c
  group Source Group 8
    ./: 8.c
  group Source Group 9
    ./: 9.c
  group Source Group 10
    ./: 10.c
  group Source Group 11
    ./: 11.c
  group Source Group 12
    ./: 12.c
  group Source Group 13
    ./: 13.c
  group Source Group 14
    ./: 14.c
  group Source Group 15
    ./: 15.c
